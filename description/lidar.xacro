Commit message: Update lidar.xacro
changed colour

File: description/lidar.xacro (robot description, xacro)
@@ -52,5 +52,5 @@
             </plugin>
         </sensor>
-        <material>Gazebo/Red</material>
+        <material>Gazebo/Orange</material>
     </gazebo>
 </robot>
